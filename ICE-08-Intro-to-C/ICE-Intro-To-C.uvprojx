# Keil uVision project ICE-Intro-To-C.uvprojx, settings and files
target ICE-08-Intro-To-C (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\drivers\include;..\peripherals\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group peripherals
    ../peripherals/c/: ws2812b.s ws2812b_ice.c
  group Lib
    ../lib/: ECE353-Validate.lib
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
